<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>light_switch</project>
        <configuration>srf05_cc2530</configuration>
      </member>
      <member>
        <project>light_switch</project>
        <configuration>srf05_cc2530_91</configuration>
      </member>
      <member>
        <project>per_test</project>
        <configuration>srf05_cc2530</configuration>
      </member>
      <member>
        <project>per_test</project>
        <configuration>srf05_cc2530_91</configuration>
      </member>
      <member>
        <project>spectrum_analyzer</project>
        <configuration>srf05_cc2530</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


